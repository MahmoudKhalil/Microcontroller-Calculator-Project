# IAR project blinky.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: TM4C123GH6PM TexasInstruments TM4C123GH6PM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: ewarm; PART_TM4C123GH6PM; TARGET_IS_TM4C123_RB1
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.CCIncludePath2: ..\..\..\..
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  AARM.AUserIncludes: ..\..\..\..
  OBJCOPY.OOCOutputFile: blinky.bin
  ILINK.IlinkOutputFile: blinky.out
  ILINK.IlinkIcfFile: blinky.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Libraries
    ../../../../driverlib/ewarm/Exe/: driverlib.a
  group Source
    ./: blinky.c delay.c delay.h keypad.c keypad.h lcd.c lcd.h parser.c parser.h startup_ewarm.c
